## conf/distro/secgw.conf
```bitbake
require conf/distro/poky.conf

DISTRO = "secgw"
DISTRO_NAME = "SecGW Distro"
DISTRO_VERSION = "0.1"

INIT_MANAGER = "systemd"
```
